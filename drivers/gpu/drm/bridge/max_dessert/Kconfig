## drivers/gpu/drm/bridge/max_dessert/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config DRM_MAX_DESSERT
	tristate
	depends on DRM
```
